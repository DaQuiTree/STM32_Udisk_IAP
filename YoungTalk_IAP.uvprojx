# Keil uVision project YoungTalk_IAP.uvprojx, settings and files
target Target (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Udisk_IAP +hex
  AfterMake: E:\Keil\keil5\ARM\ARMCC\bin\fromelf.exe --bin --output .\Objects\Young_IAP.bin .\Objects\Young_IAP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\inc;.\Lib\SRC;.\System;.\Basic\sys;.\Basic\delay;.\Basic\i2c;.\Basic\usart;.\User;.\Hardware\OLED0561;.\Hardware\LED;.\Hardware\TOUCH_KEY;.\Basic\flash;.\Hardware\CH376;.\Hardware\KEY;.\Basic\spi
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartupCode
    ./StartupCode/: startup_stm32f10x_md.s
  group System
    ./System/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
    ./Lib/SRC/: stm32f10x_spi.c
  group Lib
    ./Lib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_i2c.c
  group User
    ./User/: crc.c main.c stm32f10x_it.c iap.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/flash/: flash.c
    ./Basic/spi/: spi.c
  group HardWare
    ./Hardware/LED/: led.c
    ./Hardware/CH376/: ch376.c filesys.c
    ./Hardware/KEY/: key.c
  group Doc
    ./Doc/: issue.txt
